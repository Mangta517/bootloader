# Keil uVision project stm32f407vet6led_blink.uvprojx, settings and files
target stm32f407vet6led_blink (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8008000-0x800917F) CLOCK(16000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f407vet6led_blink +hex
  AfterMake: "D:\32 51\51\ARM\ARMCC\bin\fromelf.exe" --bin --output=".\stm32f407vet6led_blink\stm32f407vet6led_blink.raw" ".\stm32f407vet6led_blink\stm32f407vet6led_blink.axf"
  AfterMake: "D:\Python312\python.exe" "..\tools\make_update_bin.py" ".\stm32f407vet6led_blink\stm32f407vet6led_blink.raw" ".\stm32f407vet6led_blink\stm32f407vet6led_blink.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F407xx,USER_VECT_TAB_ADDRESS,VECT_TAB_OFFSET=0x8000
  c include: ../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  memory RVCT4: ROM 0x08008000 size 0x1180
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Startup
    ./: startup_stm32f407xx.s
  group Core
    ../Core/Src/: main.c system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
